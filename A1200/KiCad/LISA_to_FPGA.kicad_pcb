# Repository jbilander/Lisa_to_FPGA

File README.md:

# Lisa_to_FPGA
A small adapter-board that connects 24-bit RGB, 14 MHz CLK, PIXELSW and SYNC-signals on Lisa to a FPGA-board via a 5V-tolerant buffer.

Board is 37 x 55 mm 4-layers, hence should only be $2 for 5 PCBs at JLC.

Stackup:<br />
* Signal/GND
* GND
* 3V3
* Signal/GND

WORK IN PROGRESS, NOT TESTED YET!

***

<br />

***

BOM Rev. A
---------
Designator  | Name/Value   | Package | Notes
-|-|-|-|
U1 | Voltage Regulator 3.3V, <br /> LM1117-3.3 or <br /> AMS1117-3.3 | SOT-223 | 3.3V 1A Low Drop-Out (LDO) [Voltage regulator](https://www.aliexpress.com/item/32869037691.html).
U2-U5 | Bus Transceiver 74LVC245A  | TSSOP-20 | [74LVC245APW-T](https://www.mouser.com/ProductDetail/771-74LVC245APW-T)
U5 | PLCC-84 Through Hole Socket | PLCC-84 TH | [Preci-dip](https://www.mouser.com/ProductDetail/437-5408808424008)<br />[3M](https://www.mouser.com/ProductDetail/517-8484-11B1-RK-TP)<br />[Mill-Max](https://www.mouser.com/ProductDetail/575-948424)<br />[Adam-Tech](https://www.digikey.com/en/products/detail/adam-tech/PLCC-84-AT/9832990)<br />[A-CCS Tin](https://www.digikey.com/en/products/detail/assmann-wsw-components/A-CCS-084-Z-T/5023770)<br />[A-CCS Gold](https://www.digikey.com/en/products/detail/assmann-wsw-components/A-CCS-084-G-T/6674126)<br />[PLCC-84P DIP](https://www.aliexpress.com/item/1005002813417216.html)
C1,C2 | Capacitor 10uF | 1206 | Caps for Voltage Regulator
C3-C6 | Capacitor 0.1uF = 100nF | 0603 | Decoupling caps
R1 | 22 or 33 Ω Resistor | 0805 | 22 or 33 Ω series resistor to [avoid reflections](https://embeddeddesignblog.blogspot.com/2022/07/why-do-we-need-series-resistor-on-clock.html) on the 14 MHz CLK
J1 | VSYNC/HSYNC/CSYNC Three-Pin Header 2.54mm pitch | 2.54mm pitch | Connect a fly-lead here with connection to the HS, VS and Csync leads on the DB23-backside. 
J2 | FPC connector, Right Angle, bottom contact | 0.5mm pitch, 40 positions | [TE Connectivity 4-1734592-0](https://www.mouser.com/ProductDetail/571-4-1734592-0) or [40p here](https://www.aliexpress.com/item/10000000478377.html)

***

[![CC BY-SA 4.0][cc-by-sa-shield]][cc-by-sa]

This work is licensed under a
[Creative Commons Attribution-ShareAlike 4.0 International License][cc-by-sa].

[![CC BY-SA 4.0][cc-by-sa-image]][cc-by-sa]

[cc-by-sa]: http://creativecommons.org/licenses/by-sa/4.0/
[cc-by-sa-image]: https://licensebuttons.net/l/by-sa/4.0/88x31.png
[cc-by-sa-shield]: https://img.shields.io/badge/License-CC%20BY--SA%204.0-lightgrey.svg

## KiCad design A1200/KiCad/LISA_to_FPGA.kicad_pcb

Parts:
C1, C2: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3, C4, C5: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: Conn_01x01; PinHeader_1x01_P2.54mm_Horizontal
J2: Conn_01x40; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
J3: USB_B_Micro; 101181940001LF
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1: 3.3uH; AOTAB201610S3R3101T
R1: 68; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 27; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2, RN3, RN4, RN5, RN6: R_Pack04; R_Array_Convex_4x0603
SW1: SW_Push; Sunrom_Tactile_Switch_3x4x2mm_SMD_2-Pin
U1: LM1117-3.3; SOT-223
U2, U3: 74LVC162244ADGG; TSSOP-48_6.1x12.5mm_P0.5mm
U4: LISA; PLCC-84_THT-Socket-HAT
U5: RP2354B; QFN40P1000X1000X90-81N-D

Connections:
1V1: C5.1, C22.2, C23.2, C24.2, L1.1, U5.10 (DVDD_1), U5.32 (DVDD_2), U5.51 (DVDD_3), U5.65 (VREG_FB)
3V3: C2.2, C4.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, R4.1, R7.1, R8.1, U1.2 (VO), U1.4 (Tab), U2.7 (VCC_1), U2.18 (VCC_2), U2.31 (VCC_3), U2.42 (VCC_4), U3.7 (VCC_1), U3.18 (VCC_2), U3.31 (VCC_3), U3.42 (VCC_4), U5.5 (IOVDD_1), U5.15 (IOVDD_2), U5.24 (IOVDD_3), U5.29 (IOVDD_4), U5.41 (IOVDD_5), U5.50 (IOVDD_6), U5.59 (ADC_AVDD), U5.60 (IOVDD_7), U5.64 (VREG_VIN), U5.68 (USB_OTP_VDD), U5.69 (QSPI_IOVDD), U5.76 (IOVDD_8)
/RGA01: RN2.5 (R4.2), U4.19 (RGA1)
/RGA02: RN2.6 (R3.2), U4.18 (RGA2)
/RGA04: RN2.8 (R1.2), U4.16 (RGA4)
/RGA05: RN1.5 (R4.2), U4.15 (RGA5)
/RGA08: RN1.8 (R1.2), U4.12 (RGA8)
/RUN: C25.1, R8.2, SW1.2, U5.35 (RUN)
/STRAP1: R7.2, U5.42 (GPIO33)
/VREG_AVDD: C3.1, R4.2, U5.61 (VREG_AVDD)
/VREG_LX: L1.2, U5.63 (VREG_LX)
B0: U3.27 (4A2), U4.29 (B0)
B0_3V3: J2.18, U3.22 (4Y2)
B1: U3.29 (4A1), U4.31 (B1)
B1_3V3: J2.17, U3.20 (4Y1)
B2: U3.30 (4A0), U4.32 (B2)
B2_3V3: J2.16, U3.19 (4Y0)
B3: U3.32 (3A3), U4.34 (B3)
B3_3V3: J2.15, U3.17 (3Y3)
B4: U3.33 (3A2), U4.35 (B4)
B4_3V3: J2.14, U3.16 (3Y2)
B5: U3.35 (3A1), U4.36 (B5)
B5_3V3: J2.13, U3.14 (3Y1)
B6: U3.36 (3A0), U4.37 (B6)
B6_3V3: J2.12, U3.13 (3Y0)
B7: U3.37 (2A3), U4.38 (B7)
B7_3V3: J2.11, U3.12 (2Y3)
BT1: J2.36, U5.47 (GPIO38)
BT2: J2.37, U5.48 (GPIO39)
BT3: J2.38, U5.49 (GPIO40_ADC0)
C14O: R3.2, U4.23 (C14OUT)
C14O_3V3: U3.23 (4Y3), U5.30 (XIN)
C28O: R1.2, U4.43 (C28OUT)
C28O_3V3: J2.1, U3.6 (1Y3)
CCK: R2.2, U4.10 (CCK)
CSYNC: J1.1, U3.41 (2A0)
CSYNC_3V3: J2.3, U3.8 (2Y0)
D16: RN6.5 (R4.2), U5.6 (GPIO8)
D17: RN6.6 (R3.2), U5.7 (GPIO9)
D18: RN6.7 (R2.2), U5.8 (GPIO10)
D19: RN6.8 (R1.2), U5.9 (GPIO11)
D20: RN5.5 (R4.2), U5.11 (GPIO12)
D21: RN5.6 (R3.2), U5.12 (GPIO13)
D22: RN5.7 (R2.2), U5.13 (GPIO14)
D23: RN5.8 (R1.2), U5.14 (GPIO15)
D24: RN4.5 (R4.2), U5.16 (GPIO16)
D25: RN4.6 (R3.2), U5.17 (GPIO17)
D26: RN4.7 (R2.2), U5.18 (GPIO18)
D27: RN4.8 (R1.2), U5.19 (GPIO19)
D28: RN3.5 (R4.2), U5.20 (GPIO20)
D29: RN3.6 (R3.2), U5.21 (GPIO21)
D30: RN3.7 (R2.2), U5.22 (GPIO22)
D31: RN3.8 (R1.2), U5.23 (GPIO23)
DQ16: RN6.4 (R4.1), U4.74 (D16)
DQ17: RN6.3 (R3.1), U4.73 (D17)
DQ18: RN6.2 (R2.1), U4.72 (D18)
DQ19: RN6.1 (R1.1), U4.71 (D19)
DQ20: RN5.4 (R4.1), U4.70 (D20)
DQ21: RN5.3 (R3.1), U4.69 (D21)
DQ22: RN5.2 (R2.1), U4.68 (D22)
DQ23: RN5.1 (R1.1), U4.67 (D23)
DQ24: RN4.4 (R4.1), U4.66 (D24)
DQ25: RN4.3 (R3.1), U4.65 (D25)
DQ26: RN4.2 (R2.1), U4.64 (D26)
DQ27: RN4.1 (R1.1), U4.63 (D27)
DQ28: RN3.4 (R4.1), U4.62 (D28)
DQ29: RN3.3 (R3.1), U4.61 (D29)
DQ30: RN3.2 (R2.1), U4.60 (D30)
DQ31: RN3.1 (R1.1), U4.59 (D31)
G0: U2.37 (2A3), U4.39 (G0)
G0_3V3: J2.26, U2.12 (2Y3)
G1: U2.38 (2A2), U4.40 (G1)
G1_3V3: J2.25, U2.11 (2Y2)
G2: U2.40 (2A1), U4.41 (G2)
G2_3V3: J2.24, U2.9 (2Y1)
G3: U2.41 (2A0), U4.42 (G3)
G3_3V3: J2.23, U2.8 (2Y0)
G4: U2.43 (1A3), U4.44 (G4)
G4_3V3: J2.22, U2.6 (1Y3)
G5: U2.44 (1A2), U4.45 (G5)
G5_3V3: J2.21, U2.5 (1Y2)
G6: U2.46 (1A1), U4.46 (G6)
G6_3V3: J2.20, U2.3 (1Y1)
G7: U2.47 (1A0), U4.47 (G7)
G7_3V3: J2.19, U2.2 (1Y0)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.2, J2.2, J2.4, J2.10, J2.35, J2.39, J2.40, J2.MP (MountPin), J3.5 (GND), J3.6 (Shield), J4.2, SW1.1, U1.1 (GND), U2.1 (1~OE), U2.4 (GND_1), U2.10 (GND_2), U2.15 (GND_3), U2.21 (GND_4), U2.24 (4~OE), U2.25 (3~OE), U2.28 (GND_5), U2.34 (GND_6), U2.39 (GND_7), U2.45 (GND_8), U2.48 (2~OE), U3.1 (1~OE), U3.4 (GND_1), U3.10 (GND_2), U3.15 (GND_3), U3.21 (GND_4), U3.24 (4~OE), U3.25 (3~OE), U3.28 (GND_5), U3.34 (GND_6), U3.39 (GND_7), U3.44 (1A2), U3.45 (GND_8), U3.46 (1A1), U3.47 (1A0), U3.48 (2~OE), U4.1 (GND), U4.33 (GND), U4.53 (GND), U5.40 (GPIO32), U5.62 (VREG_PGND), U5.81 (GND)
KBCLK: J5.1, U5.43 (GPIO34)
KBDATA: J5.2, U5.44 (GPIO35)
LINK_D0: U3.40 (2A1), U5.27 (GPIO26)
LINK_D0_BUF: J2.5, U3.9 (2Y1)
LINK_D1: U3.38 (2A2), U5.28 (GPIO27)
LINK_D1_BUF: J2.6, U3.11 (2Y2)
LINK_RET: J2.7, U5.26 (GPIO25)
unnamed: R1.1, U3.43 (1A3)
unnamed: R2.1, U5.25 (GPIO24)
unnamed: R3.1, U3.26 (4A3)
unnamed: R5.2, U5.67 (USB_DP)
unnamed: R6.2, U5.66 (USB_DM)
R0: U2.26 (4A3), U4.48 (R0)
R0_3V3: J2.34, U2.23 (4Y3)
R1: U2.27 (4A2), U4.49 (R1)
R1_3V3: J2.33, U2.22 (4Y2)
R2: U2.29 (4A1), U4.50 (R2)
R2_3V3: J2.32, U2.20 (4Y1)
R3: U2.30 (4A0), U4.51 (R3)
R3_3V3: J2.31, U2.19 (4Y0)
R4: U2.32 (3A3), U4.52 (R4)
R4_3V3: J2.30, U2.17 (3Y3)
R5: U2.33 (3A2), U4.54 (R5)
R5_3V3: J2.29, U2.16 (3Y2)
R6: U2.35 (3A1), U4.55 (R6)
R6_3V3: J2.28, U2.14 (3Y1)
R7: U2.36 (3A0), U4.57 (R7)
R7_3V3: J2.27, U2.13 (3Y0)
RGA1: RN2.4 (R4.1), U5.77 (GPIO0)
RGA2: RN2.3 (R3.1), U5.78 (GPIO1)
RGA3: RN2.7 (R2.2), U5.79 (GPIO2)
RGA03: RN2.2 (R2.1), U4.17 (RGA3)
RGA4: RN2.1 (R1.1), U5.80 (GPIO3)
RGA5: RN1.4 (R4.1), U5.1 (GPIO4)
RGA6: RN1.6 (R3.2), U5.2 (GPIO5)
RGA06: RN1.3 (R3.1), U4.14 (RGA6)
RGA7: RN1.7 (R2.2), U5.3 (GPIO6)
RGA07: RN1.2 (R2.1), U4.13 (RGA7)
RGA8: RN1.1 (R1.1), U5.4 (GPIO7)
RX: J2.9, U5.37 (GPIO29)
SWCLK: J4.1, U5.33 (SWCLK)
SWDIO: J4.3, U5.34 (SWDIO)
TX: J2.8, U5.36 (GPIO28)
USB_DM: J3.2 (D-), R6.1
USB_DP: J3.3 (D+), R5.1
VCC: C1.2, U1.3 (VI), U4.30 (VCC), U4.56 (VCC), U4.83 (VCC)

Board: 4 copper layers, 64.0 x 37.0 mm, 51 parts (28 on the bottom side), 132 nets.

## KiCad design KiCad/LISA_to_FPGA.kicad_pcb

Parts:
C1, C2: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3, C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
J2: Conn_01x40; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
R1: 33 Ω; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LM1117-3.3; SOT-223
U2, U3, U4, U5: 74LVC245A; TSSOP-20_4.4x6.5mm_P0.65mm
U6: LISA; PLCC-84_THT-Socket-HAT

Connections:
3V3: C2.2, C3.2, C4.2, C5.2, C6.2, U1.2 (VO), U1.4 (Tab), U2.1 (DIR), U2.20 (VCC), U3.1 (DIR), U3.20 (VCC), U4.1 (DIR), U4.20 (VCC), U5.1 (DIR), U5.20 (VCC)
/C14M_3V3: J2.1, R1.1
B0: U3.5 (A3), U6.29 (B0)
B0_3V3: J2.18, U3.15 (B3)
B1: U3.6 (A4), U6.31 (B1)
B1_3V3: J2.17, U3.14 (B4)
B2: U3.7 (A5), U6.32 (B2)
B2_3V3: J2.16, U3.13 (B5)
B3: U3.8 (A6), U6.34 (B3)
B3_3V3: J2.15, U3.12 (B6)
B4: U3.9 (A7), U6.35 (B4)
B4_3V3: J2.14, U3.11 (B7)
B5: U2.2 (A0), U6.36 (B5)
B5_3V3: J2.13, U2.18 (B0)
B6: U2.3 (A1), U6.37 (B6)
B6_3V3: J2.12, U2.17 (B1)
B7: U2.4 (A2), U6.38 (B7)
B7_3V3: J2.11, U2.16 (B2)
C14OUT: U2.9 (A7), U6.23 (C14OUT)
C14OUT_3V3: R1.2, U2.11 (B7)
CSYNC: J1.1, U2.5 (A3)
CSYNC_3V3: J2.9, U2.15 (B3)
G0: U4.5 (A3), U6.39 (G0)
G0_3V3: J2.26, U4.15 (B3)
G1: U4.6 (A4), U6.40 (G1)
G1_3V3: J2.25, U4.14 (B4)
G2: U4.7 (A5), U6.41 (G2)
G2_3V3: J2.24, U4.13 (B5)
G3: U4.8 (A6), U6.42 (G3)
G3_3V3: J2.23, U4.12 (B6)
G4: U4.9 (A7), U6.44 (G4)
G4_3V3: J2.22, U4.11 (B7)
G5: U3.2 (A0), U6.45 (G5)
G5_3V3: J2.21, U3.18 (B0)
G6: U3.3 (A1), U6.46 (G6)
G6_3V3: J2.20, U3.17 (B1)
G7: U3.4 (A2), U6.47 (G7)
G7_3V3: J2.19, U3.16 (B2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, J2.2, J2.4, J2.6, J2.8, J2.10, J2.MP (MountPin), U1.1 (GND), U2.10 (GND), U2.19 (~OE), U3.10 (GND), U3.19 (~OE), U4.10 (GND), U4.19 (~OE), U5.2 (A0), U5.3 (A1), U5.4 (A2), U5.10 (GND), U5.19 (~OE), U6.1 (GND), U6.33 (GND), U6.53 (GND)
HSYNC: J1.2, U2.7 (A5)
HSYNC_3V3: J2.5, U2.13 (B5)
PIXELSW: U2.6 (A4), U6.28 (PIXELSW)
PIXELSW_3V3: J2.7, U2.14 (B4)
R0: U5.5 (A3), U6.48 (R0)
R0_3V3: J2.34, U5.15 (B3)
R1: U5.6 (A4), U6.49 (R1)
R1_3V3: J2.33, U5.14 (B4)
R2: U5.7 (A5), U6.50 (R2)
R2_3V3: J2.32, U5.13 (B5)
R3: U5.8 (A6), U6.51 (R3)
R3_3V3: J2.31, U5.12 (B6)
R4: U5.9 (A7), U6.52 (R4)
R4_3V3: J2.30, U5.11 (B7)
R5: U4.2 (A0), U6.54 (R5)
R5_3V3: J2.29, U4.18 (B0)
R6: U4.3 (A1), U6.55 (R6)
R6_3V3: J2.28, U4.17 (B1)
R7: U4.4 (A2), U6.57 (R7)
R7_3V3: J2.27, U4.16 (B2)
VCC: C1.2, U1.3 (VI), U6.30 (VCC), U6.56 (VCC), U6.83 (VCC)
VSYNC: J1.3, U2.8 (A6)
VSYNC_3V3: J2.3, U2.12 (B6)

Board: 4 copper layers, 54.9 x 37.0 mm, 15 parts (4 on the bottom side), 62 nets.

## Commit log (part)

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2023-08-23 Create LICENSE
2023-09-07 Added KiCad files
2023-09-08 Added footprint
2023-09-09 more place and route
2023-09-13 routing and silkscreen fixes
2023-09-13 Added screenshot pics
2023-09-13 moved A1200-version into its own folder
2023-09-13 Added schematic pdf
2023-09-13 Added photoshop image
2024-06-23 Redesign of adapter on a 2-layer PCB, changed to 74LVC16244ADGG level shifters, changed sampling clock to C28OUT now sent to the FPGA

Notices in the files:
A1200/KiCad/LISA_to_FPGA.kicad_pcb:
(C) 2023,2024,2026
KiCad/LISA_to_FPGA.kicad_pcb:
(C) 2023
